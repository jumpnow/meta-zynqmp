FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

HDF_BASE_db-zynqmp = "file://"
HDF_PATH_db-zynqmp = "db-zcu102.xsa"

HDF_BASE_ultra96-zynqmp = "file://"
HDF_PATH_ultra96-zynqmp = "ultra96v2.xsa"
