do_compile[mcdepends] = "multiconfig::pmu:pmu-firmware:do_deploy"
