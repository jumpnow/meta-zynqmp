FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

DEVICE_TREE_NAME_zcu102-zynqmp = "zynqmp-zcu102-rev1.0.dtb"
DEVICE_TREE_NAME_zcu102x-zynqmp = "zynqmp-zcu102-rev1.0.dtb"
DEVICE_TREE_NAME_ultra96-zynqmp = "zynqmp-zcu100-revC.dtb"
