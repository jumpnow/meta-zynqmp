FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-Load-built-in-config-object-at-boot.patch \
            file://0002-Add-pm-cfg-obj.patch \
"
